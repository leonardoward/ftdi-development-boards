# Repository leonardoward/ftdi-development-boards

File README.md:

# FTDI Development Board - FT260S and FT312D #

This repository contains the design of a development board for the [FT260S](https://www.digikey.com/en/products/detail/ftdi-future-technology-devices-international-ltd/FT260S-U/6124909) and the [FT312D](https://www.digikey.com/en/products/detail/ftdi-future-technology-devices-international-ltd/FT312D-32L1C-R/4047486). The PCB was designed using KiCad.

## Table of Contents

1. [Hardware Design](#hardware-design)
    1. [USB C Port with Electromagnetic Compatibility EMC](#usb-c-port-with-electromagnetic-compatibility-emc)
    2. [FTDI 1 FT260S](#ftdi-1-ft260s)
    3. [FTDI 2 FT312D](#ftdi-2-ft312d)
    4. [ESP32 with Auto Reset](#esp32-with-auto-reset)
    5. [SPDT Switch](#spdt-switch)
2. [Bill of Materials](#bill-of-materials)
3. [PCB](#pcb)
4. [Testing](#testing)
    1. [ESP32 with Auto Reset](#esp32-with-auto-reset)

## Hardware Design

The design includes the following circuits:

**[Back to top](#table-of-contents)**

### USB C Port with Electromagnetic Compatibility EMC

Everything starts with the USB C port, this type of USB was selected because it's size and because of the growing trend of using this port to charge and communicate with portable devices.

The design includes [Transient Voltage Suppression (TVS) diodes](https://www.digikey.com/en/products/detail/comchip-technology/CPDT6-5V4-HF/1121118) and [Ferrite Beads](https://www.digikey.com/en/products/detail/fair-rite-products-corp/2508056017Y0/8594301) to reduce the Electromagnetic Interference (EMI). These [protections for the USB](https://www.rs-online.com/designspark/usb-port-protection) port will add compliance with the [EMC regulations and standards](https://learnemc.com/emc-regulations-and-standards) from the  Federal Communications Commission (FCC) and the European Union.

**[Back to top](#table-of-contents)**

### FTDI 1 FT260S

The first USB TO UART/I2C FTDI that we is being tested is the [FT260S-U](https://www.digikey.com/en/products/detail/ftdi-future-technology-devices-international-ltd/FT260S-U/6124909). The design only considers the USB to UART, therefore the I2C is left unconnected.

**Notes:** The FT260S was originally selected to directly program the ESP32, and also provide serial communication. After careful consideration I found that the FT260 is a HID class device and as such it does not generate a Virtual COM Port (like the FT232R), to interface with the FT260 it can be used the official helper library, LibFT260.

https://www.ftdichip.com/Support/Documents/AppNotes/AN_394_User_Guide_for_FT260.pdf
https://www.ftdichip.com/Support/Documents/AppNotes/AN_395_User_Guide_for_LibFT260.pdf

For that reason the FT260S will require more work before it can seamlessly program the ESP32. This topic will have to be addressed in the future.

**[Back to top](#table-of-contents)**

### FTDI 2 FT312D

The second USB TO UART/I2C FTDI that is being tested is the [FT312D-32L1C-R](https://www.digikey.com/en/products/detail/ftdi-future-technology-devices-international-ltd/FT312D-32L1C-R/4047486). This IC does not support DTR/DSR for the UART, a feature that is required for the auto reset circuit of the [ESP32](https://www.digikey.com/en/products/detail/espressif-systems/ESP32-WROOM-32D-4MB/9381716) that was implemented, nevertheless the PCB has it as a second alternative.

**[Back to top](#table-of-contents)**

### ESP32 with Auto Reset

Finally, the [ESP32](https://www.digikey.com/en/products/detail/espressif-systems/ESP32-WROOM-32D-4MB/9381716). The design includes an auto reset circuit that uses RTS and DTR to reset and put in bootloader mode the ESP32. For more information about this circuit, these blogs [1](https://forum.micropython.org/viewtopic.php?f=18&t=4966) [2](https://forums.adafruit.com/viewtopic.php?f=57&p=483993#p487891) can be useful.

**[Back to top](#table-of-contents)**

### SPDT Switch

The design includes a couple of [TS5A3153DCUR](https://www.digikey.com/en/products/detail/texas-instruments/TS5A3153DCUR/1216791) that will be tested for future implementations.

**[Back to top](#table-of-contents)**

## Bill of Materials ##

| Reference | Quantity |
| ------------- | ------------- |
| [1 µF ±10% 10V Ceramic Capacitor X7R 0805 (2012 Metric)](https://www.digikey.com/en/products/detail/samsung-electro-mechanics/CL21B105KPFNNNE/3886933)  | 2 |
| [47 pF ±5% 16V Ceramic Capacitor C0G, NP0 0805 (2012 Metric)](https://www.digikey.com/en/products/detail/w%C3%BCrth-elektronik/885012007014/5453673)  | 6 |
| [0.1 µF ±10% 50V Ceramic Capacitor X7R 0805 (2012 Metric)](https://www.digikey.com/en/products/detail/avx-corporation/08055C104KAT2A/563505)  | 3 |
| [4.7 µF ±10% 6.3V Ceramic Capacitor X5R 0805 (2012 Metric)](https://www.digikey.com/en/products/detail/samsung-electro-mechanics/CL21A475KQFNNNE/3886856)  | 3 |
| [15V Clamp 5A (8/20µs) Ipp Tvs Diode Surface Mount SOT-23-6](https://www.digikey.com/en/products/detail/comchip-technology/CPDT6-5V4-HF/1121118)  | 1 |
| [Red 630nm LED Indication - Discrete 1.9V 0805 (2012 Metric)](https://www.digikey.com/en/products/detail/w%C3%BCrth-elektronik/150080SS75000/4489921)  | 3 |
| [1 Signal Line Ferrite Bead 0805 (2012 Metric) 300mA 350mOhm](https://www.digikey.com/en/products/detail/fair-rite-products-corp/2508056017Y0/8594301)  | 2 |
| [USB-C (USB TYPE-C) USB 3.2 Gen 2 (USB 3.1 Gen 2, Superspeed + (USB 3.1)) Receptacle Connector 24 Position Board Cutout, Surface Mount, Right Angle; Through Hole](https://www.digikey.com/en/products/detail/cui-devices/UJ31-CH-G2-SMT-TR/8024057)  | 1 |
| [Bipolar (BJT) Transistor NPN 30 V 600 mA 250MHz 300 mW Surface Mount SOT-23-3 (TO-236)](https://www.digikey.com/en/products/detail/onsemi/MMBT2222LT1G/919595)  | 2 |
| [10 kOhms ±1% 0.125W, 1/8W Chip Resistor 0805 (2012 Metric)](https://www.digikey.com/en/products/detail/vishay-dale/CRCW080510K0FKEAC/7928398)  | 4 |
| [5.1 kOhms ±1% 0.125W, 1/8W Chip Resistor 0805 (2012 Metric)](https://www.digikey.com/en/products/detail/stackpole-electronics-inc/RMCF0805FT5K10/1760394)  | 2 |
| [27 Ohms ±1% 0.125W, 1/8W Chip Resistor 0805 (2012 Metric)](https://www.digikey.com/en/products/detail/stackpole-electronics-inc/RMCF0805FT27R0/1712920)  | 4 |
| [620 Ohms ±5% 0.125W, 1/8W Chip Resistor 0805 (2012 Metric)](https://www.digikey.com/en/products/detail/yageo/RC0805JR-07620RL/728357)  | 3 |
| [1 Circuit IC Switch 2:1 900mOhm 8-VSSOP](https://www.digikey.com/en/products/detail/texas-instruments/TS5A3153DCUR/1216791)  | 2 |
| [ESP32-WROOM-32D (4MB)](https://www.digikey.com/en/products/detail/espressif-systems/ESP32-WROOM-32D-4MB/9381716)  | 1 |
| [IC REG LINEAR 3.3V 1A 8SOIC](https://www.digikey.com/en/products/detail/diodes-incorporated/AP2115M-3-3TRG1/5305574)  | 1 |
| [FT260S-U IC USB TO UART/I2C 28-TSSOP](https://www.digikey.com/en/products/detail/ftdi-future-technology-devices-international-ltd/FT260S-U/6124909)  | 1 |
| [FT312D-32L1C-R IC USB HOST CTRL 32-LQFP](https://www.digikey.com/en/products/detail/ftdi-future-technology-devices-international-ltd/FT312D-32L1C-R/4047486)  | 1 |
| [12 MHz ±30ppm Crystal 18pF 35 Ohms HC-49/US](https://www.digikey.com/en/products/detail/jauch-quartz/J49SMH-F-G-G-K-12M0/10416018)  | 1 |
| [Conn Header 40POS 2.54](https://www.digikey.com/en/products/detail/3m/2340-6111TG/1237275)  | 3 |

**[Back to top](#table-of-contents)**

## PCB

**[Back to top](#table-of-contents)**

## Testing

### ESP32 with Auto Reset

The designed auto reset circuit requires the signals 3.3V, GND, TX, RX, RTS and DTR. The commercial [USB to Serial Converter](https://www.amazon.com/gp/product/B075N82CDL/ref=ppx_yo_dt_b_asin_title_o04_s00?ie=UTF8&language=en_US&psc=1) (FT232RL) was used to test the circuit, it provides all the required signals.

The following wiring diagram shows how to connect the commercial [USB to Serial Converter](https://www.amazon.com/gp/product/B075N82CDL/ref=ppx_yo_dt_b_asin_title_o04_s00?ie=UTF8&language=en_US&psc=1) and our FTDI Development Board.

Once the 2 boards were connected and the [USB to Serial Converter](https://www.amazon.com/gp/product/B075N82CDL/ref=ppx_yo_dt_b_asin_title_o04_s00?ie=UTF8&language=en_US&psc=1) was plugged, the PC (in Windows) recognized the device and it was ready to use. Check if you need to install drivers associated to the FTDI, that is often the case.

**Note:** Before testing the following code, verify that the ESP-IDF is installed and the Arduino IDE can program ESP devices.

The code used is very simple, the ESP32 sends a "Hello world" message through the serial communication every second.

```
void setup() {
   Serial.begin(115200);
}

void loop() {
   Serial.println("Hello World");
   delay(1000);
}
```
The standard Arduino IDE was used to program the ESP32, with the following configurations:

And the test was successful, the following image shows the results in the serial monitor.

**[Back to top](#table-of-contents)**

## KiCad design ftdi-testing-board/ftdi-testing-board.kicad_pcb

Parts:
C1, C2: 1uF; C_0805_2012Metric; Manufacturer_Part_Number CL21B105KPFNNNE
C3, C4, C7, C8, C9, C10: 47pF; C_0805_2012Metric; Manufacturer_Part_Number 885012007014
C5, C6, C11: 100nF; C_0805_2012Metric; Manufacturer_Part_Number 08055C104KAT2A
C12, C13, C14: 4.7uF; C_0805_2012Metric; Manufacturer_Part_Number CL21A475KQFNNNE
D1: CPDT6-5V4-HF; SOT-23-6_Handsoldering; Manufacturer_Part_Number CPDT6-5V4-HF
D2, D3, D4: RED-CLEAR; LED_0805_2012Metric; Manufacturer Part Number 150080SS75000
FB1, FB2: 350m; R_0805_2012Metric; Manufacturer_Part_Number 2508056017Y0
J1, J4: Conn_01x14_Male; PinSocket_1x14_P2.54mm_Vertical
J2, J11, J13: Conn_01x06_Male; PinSocket_1x06_P2.54mm_Vertical
J3: UJ31-CH-G2-SMT-TR; UJ31CHG2SMTTR; Manufacturer_Part_Number UJ31-CH-G2-SMT-TR
J5: Conn_01x10_Male; PinSocket_1x10_P2.54mm_Vertical
J6: Conn_01x08_Male; PinSocket_1x08_P2.54mm_Vertical
J7, J9, J10: Conn_01x04_Male; PinSocket_1x04_P2.54mm_Vertical
J8, J12: Conn_01x05_Male; PinSocket_1x05_P2.54mm_Vertical
Q1, Q2: MMBT2222LT1G; SOT-23; Manufacturer_Part_Number MMBT2222LT1G
R1, R2, R5, R6: 10K; R_0805_2012Metric; Manufacturer_Part_Number CRCW080510K0FKEAC
R3, R4: 5.1k; R_0805_2012Metric; Manufacturer_Part_Number RMCF0805FT5K10
R7, R8, R9, R10: 27; R_0805_2012Metric; Manufacturer_Part_Number RMCF0805FT27R0
R11, R12, R13: 620; R_0805_2012Metric; Manufacturer_Part_Number RC0805JR-07620RL
U1, U2: TS5A3153DCUR; VSSOP-8_2.3x2mm_P0.5mm; Manufacturer_Part_Number TS5A3153DCUR
U3: ESP32-WROOM-32D; Manufacturer_Part_Number ESP32-WROOM-32D; Mouser Part Number N/A
U5: AP2115M-3.3TRG1; SOIC-8_3.9x4.9mm_P1.27mm; Manufacturer_Part_Number AP2115M-3.3TRG1
U8: FT260S-U; TSSOP-28_4.4x9.7mm_P0.65mm; Manufacturer_Part_Number FT260S-U
U9: FT312D-32L1C-R; LQFP-32_7x7mm_P0.8mm; Manufacturer_Part_Number FT312D-32L1C-R
XTAL1: J49SMH-F-G-G-K-12M0; Crystal_SMD_HC49-SD_HandSoldering; Manufacturer_Part_Number J49SMH-F-G-G-K-12M0

Connections:
3V3_FT260: J11.6, U8.5 (DEBUGGER), U8.6 (STEST_RSTN), U8.7 (RESETN), U8.9 (DCNF1), U8.10 (VCCIO), U8.26 (VOUT3V3)
+3V3: J1.2, J2.6, R5.1, R6.1, U3.2 (3V3)
CLK: J5.5, U3.20 (CLK/SCK/IO6)
CMD: J5.6, U3.19 (CMD/SCS/IO11)
ESP_EN: C2.1, J1.3, Q2.3, R6.2, U3.3 (EN)
ESP_IO0: C1.1, J4.14, Q1.3, R5.2, U3.25 (IO0)
ESP_IO2: J5.1, U3.24 (IO2)
ESP_IO4: J4.13, U3.26 (IO4)
ESP_IO5: J4.10, U3.29 (IO5)
ESP_IO12: J1.14, U3.14 (IO12)
ESP_IO13: J5.9, U3.16 (IO13)
ESP_IO14: J1.13, U3.13 (IO14)
ESP_IO15: J5.2, U3.23 (IO15)
ESP_IO16: J4.12, U3.27 (IO16)
ESP_IO17: J4.11, U3.28 (IO17)
ESP_IO18: J4.9, U3.30 (IO18)
ESP_IO19: J4.8, U3.31 (IO19)
ESP_IO21: J4.6, U3.33 (IO21)
ESP_IO22: J4.3, U3.36 (IO22)
ESP_IO23: J4.2, U3.37 (IO23)
ESP_IO25: J1.10, U3.10 (IO25)
ESP_IO26: J1.11, U3.11 (IO26)
ESP_IO27: J1.12, U3.12 (IO27)
ESP_IO32: J1.8, U3.8 (IO32)
ESP_IO33: J1.9, U3.9 (IO33)
ESP_IO34: J1.6, U3.6 (IO34)
ESP_IO35: J1.7, U3.7 (IO35)
ESP_RX: J2.4, J4.5, U3.34 (RXD0/IO3)
ESP_TX: J2.5, J4.4, U3.35 (TXD0/IO1)
GND: C1.2, C2.2, J1.1, J2.1, J4.1, J5.10, U3.1 (GND_1), U3.15 (GND_2), U3.38 (GND_3), U3.39 (GND_4)
GND1: D1.2, D1.5, J3.A1 (GND_1), J3.A12 (GND_2), J3.B1 (GND_3), J3.B12 (GND_4), J3.S1 (GND_5), J3.S2 (GND_6), J3.S3 (GND_7), J3.S4 (GND_8), J7.1, R3.2, R4.2
GND2: C3.2, C4.2, C6.2, C8.2, C10.2, C11.2, C12.2, C14.2, D3.1 (K), J9.1, J13.1, U5.6 (GND_1), U5.7 (GND_2), U9.1 (GND_1), U9.6 (GND_2), U9.8 (TEST1), U9.14 (GND_3), U9.15 (GND_4), U9.16 (GND_5), U9.19 (GND_6), U9.27 (GND_7)
GND3: C5.2, C7.2, C9.2, C13.2, D4.1 (K), J10.1, J11.1, J12.1, U8.8 (DCNF0), U8.23 (GND), U8.28 (AGND)
GNDA: J6.1, J8.1, U1.3 (GND), U1.4 (GND), U2.3 (GND), U2.4 (GND)
unnamed: C3.1, J9.2, R8.2
unnamed: C4.1, J9.3, R7.2
unnamed: C7.1, J10.2, R10.2
unnamed: C8.1, U9.4 (XTIN), XTAL1.1
unnamed: C9.1, J10.3, R9.2
unnamed: C10.1, U9.5 (XTOUT), XTAL1.2
unnamed: C11.1, U9.3 (AVCC), U9.7 (VREGOUT)
unnamed: C12.1, J9.4, U5.5 (EN), U5.8 (VIN)
unnamed: C5.1, C13.1, J10.4, U8.2 (VBUS_DET), U8.27 (VCCIN)
unnamed: C6.1, C14.1, J13.6, R11.1, U5.1 (VOUT), U9.2 (VCC), U9.9 (TEST2), U9.10 (RESET#), U9.13 (VCCIO_1), U9.22 (VCCIO_2), U9.28 (VCCIO_3)
unnamed: D1.1, FB2.2, J3.A6 (DP1), J3.B6 (DP2)
unnamed: D1.3, FB1.2, J3.A7 (DN1), J3.B7 (DN2)
unnamed: D1.4, J3.A4 (V_BUS_1), J3.A9 (V_BUS_2), J3.B4 (VBUS_1), J3.B9 (VBUS_2), J7.4
unnamed: D2.1 (K), U9.32 (USB_ERROR#)
unnamed: D2.2 (A), R11.2
unnamed: D3.2 (A), R12.2
unnamed: D4.2 (A), R13.2
unnamed: FB1.1, J7.3
unnamed: FB2.1, J7.2
unnamed: J2.2, Q1.2, R2.2
unnamed: J2.3, Q2.2, R1.2
unnamed: J3.A5 (CC1), R4.1
unnamed: J3.B5 (CC2), R3.1
unnamed: J6.2, U2.2 (EN)
unnamed: J6.3, U2.5 (IN)
unnamed: J6.4, U2.1 (COM)
unnamed: J6.5, U1.2 (EN)
unnamed: J6.6, U1.5 (IN)
unnamed: J6.7, U1.1 (COM)
unnamed: J6.8, U1.8 (V+), U2.8 (V+)
unnamed: J8.2, U2.6 (NO)
unnamed: J8.3, U2.7 (NC)
unnamed: J8.4, U1.6 (NO)
unnamed: J8.5, U1.7 (NC)
unnamed: J11.2, U8.13 (DIO2/CTSN)
unnamed: J11.3, U8.12 (DIO1/RTSN)
unnamed: J11.4, U8.14 (DIO3/RXD)
unnamed: J11.5, U8.15 (DIO4/TXD)
unnamed: J12.2, U8.4 (DIO13/DSRN)
unnamed: J12.3, U8.22 (DIO11/RI)
unnamed: J12.4, U8.21 (DIO10/DCD)
unnamed: J12.5, U8.20 (DIO9/DTRN)
unnamed: J13.2, U9.26 (CTS#)
unnamed: J13.3, U9.25 (RTS#)
unnamed: J13.4, U9.24 (RXD)
unnamed: J13.5, U9.23 (TXD)
unnamed: Q1.1, R1.1
unnamed: Q2.1, R2.1
unnamed: R7.1, U9.18 (USBDM)
unnamed: R8.1, U9.17 (USBDP)
unnamed: R9.1, U8.24 (DM)
unnamed: R10.1, U8.25 (DP)
unnamed: R12.1, U9.29 (TX_ACTIVE)
unnamed: R13.1, U8.11 (DIO0/TX_ACTIVE)
SD0: J5.4, U3.21 (SD0/SDO/IO7)
SD1: J5.3, U3.22 (SD1/SDI/IO8)
SD2: J5.8, U3.17 (SD2/SDH/IO9)
SD3: J5.7, U3.18 (SD3/SWP/IO10)
SENSOR_VN: J1.5, U3.5 (SENSOR_VN/IO39)
SENSOR_VP: J1.4, U3.4 (SENSOR_VP/IO36)

Notes on the sheet:
GND
USB-C 1
FT312D
CTS
RTS
FT260S
DSRN
DCD
DTRN
3V3
DTR
AUTO RESET
ESP32
IC SWITCH
NO2
NO1
NC1
NC2
COM1
IN1
EN1
COM2
IN2
EN2

Board: 2 copper layers, 104.0 x 81.0 mm, 55 parts (0 on the bottom side), 94 nets.

## Commit log

2021-08-02 Added KiCad project and FTDI ICs to the schematic
2021-08-02 Added capacitors to schematic
2021-08-03 Added USB C, TVS and Ferrite Beads to Schematic
2021-08-04 Added components for the FT312D, the FT260S and the auto reset circuit for the ESP
2021-08-05 Finished schematic
2021-08-05 Changed footprint for header J2
2021-08-05 Added Gerber Files, BOM and 3D Model exports
2021-08-12 Added images to the README
2021-10-16 Added images
2021-10-16 Added menu
2021-10-16 Fixed errors
